# Keil uVision project gujianku.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gujianku
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,EMPL_TARGET_STM32F4,MPU9250,USE_HAL_DRIVER,STM32F429xx,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: .\sys;.\OLED;..\example-gnn - 1;.\;.\DMP\driver\eMPL;.\DMP\driver\include;.\DMP\driver\stm32L;.\DMP\eMPL-hal;.\DMP\mllite;.\DMP\mpl;.\IIC;.\MPU9250
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
  group user
    ./: delay.c delay.h time.c ursat.c ursat.h ultrasontic.c ultrasontic.h hc05.c hc05.h motor.c motor.h i2c.c i2c.h hongwai.c hongwai.h encode.c encode.h ano.c ano.h pid.c pid.h motion.c motion.h
    ./OLED/: oled.c
    ./IIC/: myiic.c
    ./MPU9250/: mpu9250.c
  group system
    ./sys/: sys.c sys.h
  group dmp
    ./DMP/driver/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
    ./DMP/driver/include/: log.h mlinclude.h mlmath.h mlos.h mltypes.h mpu.h stdint_invensense.h
    ./DMP/driver/stm32L/: log_stm32.c packet.h
    ./DMP/eMPL-hal/: eMPL_outputs.c eMPL_outputs.h
    ./DMP/mllite/: data_builder.c data_builder.h hal_outputs.c hal_outputs.h invensense.h message_layer.c message_layer.h ml_math_func.c ml_math_func.h mlmath.c mpl.c mpl.h results_holder.c results_holder.h start_manager.c start_manager.h storage_manager.c storage_manager.h
    ./DMP/mpl/: accel_auto_cal.h compass_vec_cal.h fast_no_motion.h fusion_9axis.h gyro_tc.h heading_from_gyro.h inv_math.h invensense_adv.h libmpllib.lib mag_disturb.h motion_no_motion.h no_gyro_fusion.h quaternion_supervisor.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.3.1, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
